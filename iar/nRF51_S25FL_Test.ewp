# IAR project nRF51_S25FL_Test.ewp, settings and files
configuration nrf51822 (ARM)
  General.OGChipSelectEditMenu: nRF51822-QFAA NordicSemi nRF51822-QFAA
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: NRF51; SPI_MASTER_0_ENABLE
  ICCARM.CCIncludePath2: ..\src\nrf51_sdk_v810\config; ..\src\nrf51_sdk_v810; ..\src\nrf51_sdk_v810\bsp; ..\src\nrf51_sdk_v810\components\libraries\util; ..\src\nrf51_sdk_v810\components\drivers_nrf\hal; ..\src\nrf51_sdk_v810\components\drivers_nrf\spi_master; ..\src\nrf51_sdk_v810\components\device; ..\src\nrf51_sdk_v810\components\toolchain; ..\src\nrf51_sdk_v810\components\libraries\button; ..\src\nrf51_sdk_v810\components\drivers_nrf\gpiote; ..\src\nrf51_sdk_v810\components\drivers_nrf\config; ..\src\nrf51_sdk_v810\components\drivers_nrf\common; ..\src\nrf51_sdk_v810\components\libraries\timer; ..\src\nrf51_sdk_v810\components\drivers_nrf\nrf_soc_nosd; $TOOLKIT_DIR$\CMSIS\Include; ..\src\nrf51_sdk_v810\components\drivers_nrf\twi_master; ..\src\nrf51_sdk_v810\components\drivers_nrf\twi_master\incubated; ..\src\nrf51_sdk_v810\components\drivers_nrf\twi_master\incubated\config; ..\src\nrf51_sdk_v810\components\drivers_nrf\hal; ..\src\nrf51_sdk_v810\components\drivers_nrf\ppi; ..\src\nrf51_sdk_v810\components\drivers_nrf\timer
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: SPI_MASTER_0_ENABLE; BOARD_PCA10028; NRF51; SWI_DISABLE0
  OBJCOPY.OOCOutputFile: nRF51_S25FL_Test.hex
  ILINK.IlinkOutputFile: nRF51_S25FL_Test.out
  ILINK.IlinkIcfFile: nRF51_S25FL_Test_iar_nrf51_noS110.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application
    ../src/: ains.c board.h main.c pcf85.c s25fl.c
  group Device
    ../src/nrf51_sdk_v810/components/toolchain/iar/: iar_startup_nrf51.s
    ../src/nrf51_sdk_v810/components/toolchain/: system_nrf51.c
  group nRF_Drivers
    ../src/nrf51_sdk_v810/components/drivers_nrf/hal/: nrf_adc.c nrf_delay.c
    ../src/nrf51_sdk_v810/components/drivers_nrf/common/: nrf_drv_common.c
    ../src/nrf51_sdk_v810/config/: nrf_drv_config.h
    ../src/nrf51_sdk_v810/components/drivers_nrf/ppi/: nrf_drv_ppi.c
    ../src/nrf51_sdk_v810/components/drivers_nrf/timer/: nrf_drv_timer.c
    ../src/nrf51_sdk_v810/components/drivers_nrf/twi_master/: nrf_drv_twi.c
    ../src/nrf51_sdk_v810/components/drivers_nrf/nrf_soc_nosd/: nrf_soc.c
    ../src/nrf51_sdk_v810/components/drivers_nrf/spi_master/: spi_master.c
    ../src/nrf51_sdk_v810/components/drivers_nrf/twi_master/incubated/: twi_hw_master.c
    ../src/nrf51_sdk_v810/components/drivers_nrf/twi_master/incubated/config/: twi_master_config.h
  group nRF_Libraries
    ../src/nrf51_sdk_v810/components/libraries/util/: app_error.c app_util_platform.c nrf_assert.c
