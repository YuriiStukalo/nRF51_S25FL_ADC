<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\iar\nRF51_S25FL_Test.ewp</path>
  </project>
  <batchBuild/>
</workspace>